Commit message: slam

File: src/tadeocar_description/urdf/tadeocar_tf.urdf (robot description, URDF)
Before this commit: robot tadeocar_v1, 3 links, 2 joints
Joints:
- joint lidar_joint: origin xyz=0.55 0 0.39 rpy=0 0 0 -> xyz=0.55 0 0.43 rpy=0 0 0
